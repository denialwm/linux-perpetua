// SPDX-License-Identifier: (GPL-2.0 OR MIT)
/*
 * Unisoc UMS9230 DTS file
 *
 * Copyright (C) 2024 Otto Pflüger
 *
 * Based on downstream kernel DTS file,
 * Copyright (C) 2020, Unisoc Inc.

#include <dt-bindings/clock/sprd,ums9230-clk.h>
#include <dt-bindings/interrupt-controller/arm-gic.h>

/ {
	#address-cells = <2>;
	#size-cells = <2>;
	interrupt-parent = <&gic>;

	memory@80000000 {
		device_type = "memory";
		/* We expect the bootloader to fill in the reg */
		reg = <0x0 0x80000000 0x0 0x0>;
	};

	cpus {
		#address-cells = <2>;
		#size-cells = <0>;

		cpu-map {
			cluster0 {
				core0 {
					cpu = <&cpu0>;
				};
				core1 {
					cpu = <&cpu1>;
				};
				core2 {
					cpu = <&cpu2>;
				};
				core3 {
					cpu = <&cpu3>;
				};
				core4 {
					cpu = <&cpu4>;
				};
				core5 {
					cpu = <&cpu5>;
				};
			};
			cluster1 {
				core6 {
					cpu = <&cpu6>;
				};
				core7 {
					cpu = <&cpu7>;
				};
			};
		};

		cpu0: cpu@0 {
			device_type = "cpu";
			compatible = "arm,cortex-a55";
			reg = <0x0 0x0>;
			enable-method = "psci";
		};

		cpu1: cpu@100 {
			device_type = "cpu";
			compatible = "arm,cortex-a55";
			reg = <0x0 0x100>;
			enable-method = "psci";
		};

		cpu2: cpu@200 {
			device_type = "cpu";
			compatible = "arm,cortex-a55";
			reg = <0x0 0x200>;
			enable-method = "psci";
		};

		cpu3: cpu@300 {
			device_type = "cpu";
			compatible = "arm,cortex-a55";
			reg = <0x0 0x300>;
			enable-method = "psci";
		};

		cpu4: cpu@400 {
			device_type = "cpu";
			compatible = "arm,cortex-a55";
			reg = <0x0 0x400>;
			enable-method = "psci";
		};

		cpu5: cpu@500 {
			device_type = "cpu";
			compatible = "arm,cortex-a55";
			reg = <0x0 0x500>;
			enable-method = "psci";
		};

		cpu6: cpu@600 {
			device_type = "cpu";
			compatible = "arm,cortex-a75";
			reg = <0x0 0x600>;
			enable-method = "psci";
		};

		cpu7: cpu@700 {
			device_type = "cpu";
			compatible = "arm,cortex-a75";
			reg = <0x0 0x700>;
			enable-method = "psci";
		};
	};

	psci {
		compatible = "arm,psci-0.2";
		method = "smc";
	};

	timer {
		compatible = "arm,armv8-timer";
		interrupts = <GIC_PPI 13 IRQ_TYPE_LEVEL_HIGH>, /* Physical Secure PPI */
			     <GIC_PPI 14 IRQ_TYPE_LEVEL_HIGH>, /* Physical Non-Secure PPI */
			     <GIC_PPI 11 IRQ_TYPE_LEVEL_HIGH>, /* Virtual PPI */
			     <GIC_PPI 10 IRQ_TYPE_LEVEL_HIGH>; /* Hypervisor PPI */
		arm,no-tick-in-suspend;
	};

	ext_26m: clk-26m {
		compatible = "fixed-clock";
		#clock-cells = <0>;
		clock-frequency = <26000000>;
		clock-output-names = "ext-26m";
	};

	dphy_250m: dphy-250m {
		compatible = "fixed-clock";
		#clock-cells = <0>;
		clock-frequency = <250000000>;
		clock-output-names = "dphy-250m";
	};

	dphy_333m3: dphy-333m3 {
		compatible = "fixed-clock";
		#clock-cells = <0>;
		clock-frequency = <333300000>;
		clock-output-names = "dphy-333m3";
	};

	soc {
		compatible = "simple-bus";
		#address-cells = <1>;
		#size-cells = <1>;
		ranges = <0 0 0x0 0x80000000>;

		gic: interrupt-controller@10000000 {
			compatible = "arm,gic-v3";
			reg = <0x10000000 0x20000>,	/* GICD */
			      <0x10040000 0x100000>;	/* GICR */
			#interrupt-cells = <3>;
			#address-cells = <2>;
			#size-cells = <2>;
			redistributor-stride = <0x0 0x20000>;	/* 128KB stride */
			#redistributor-regions = <1>;
			interrupt-controller;
			interrupts = <GIC_PPI 9 IRQ_TYPE_LEVEL_HIGH>;
		};

		ap_apb_regs: syscon@20000000 {
			compatible = "sprd,ums9230-glbregs", "syscon", "simple-mfd";
			reg = <0x20000000 0x10000>;
			#address-cells = <1>;
			#size-cells = <1>;
			ranges = <0x0 0x20000000 0x10000>;

			apapb_gate: clock-controller@0 {
				compatible = "sprd,ums9230-apapb-gate";
				reg = <0x0 0x3000>;
				clocks = <&ext_26m>;
				clock-names = "ext-26m";
				#clock-cells = <1>;
				#reset-cells = <1>;
			};
		};

		ap_clk: clock-controller@20010000 {
			compatible = "sprd,ums9230-ap-clk";
			reg = <0x20010000 0x1000>;
			clocks = <&ext_26m>, <&dphy_250m>, <&dphy_333m3>;
			clock-names = "ext-26m", "dphy-250m", "dphy-333m3";
			#clock-cells = <1>;
		};

		sdio3: mmc@201d0000 {
			compatible = "sprd,sdhci-r11";
			reg = <0x201d0000 0x1000>;
			interrupts = <GIC_SPI 10 IRQ_TYPE_LEVEL_HIGH>;
			clocks = <&ap_clk CLK_EMMC_2X>,
				 <&apapb_gate CLK_EMMC_EB>;
			clock-names = "sdio", "enable";
			assigned-clocks = <&ap_clk CLK_EMMC_2X>;
			assigned-clock-parents = <&mpll1 CLK_RPLL>;

			status = "disabled";
		};

		aon_apb_regs: syscon@64000000 {
			compatible = "sprd,ums9230-glbregs", "syscon", "simple-mfd";
			reg = <0x64000000 0x10000>;
			#address-cells = <1>;
			#size-cells = <1>;
			ranges = <0x0 0x64000000 0x10000>;

			aon_gate: clock-controller@0 {
				compatible = "sprd,ums9230-aon-gate";
				reg = <0x0 0x3000>;
				clocks = <&ext_26m>;
				clock-names = "ext-26m";
				#clock-cells = <1>;
				#reset-cells = <1>;
			};
		};

		anlg_phy_g2_regs: syscon@64570000 {
			compatible = "sprd,ums9230-glbregs", "syscon", "simple-mfd";
			reg = <0x64570000 0x10000>;
			#address-cells = <1>;
			#size-cells = <1>;
			ranges = <0x0 0x64570000 0x10000>;

			hsphy: phy@0 {
				compatible = "sprd,ums9230-hsphy";
				reg = <0x0 0x3000>;
				sprd,syscon-aon-apb = <&aon_apb_regs>;
				#phy-cells = <0>;

				status = "disabled";
			};
		};

		anlg_phy_g3_regs: syscon@64580000 {
			compatible = "sprd,ums9230-glbregs", "syscon", "simple-mfd";
			reg = <0x64580000 0x10000>;
			#address-cells = <1>;
			#size-cells = <1>;
			ranges = <0x0 0x64580000 0x10000>;

			mpll1: clock-controller@0 {
				compatible = "sprd,ums9230-g3-pll";
				reg = <0x0 0x100>;
				clocks = <&ext_26m>;
				clock-names = "ext-26m";
				#clock-cells = <1>;
			};
		};

		usb: usb@64900000 {
			compatible = "sprd,ums9230-musb", "sprd,musb";
			reg = <0x64900000 0x2000>;
			interrupts = <GIC_SPI 69 IRQ_TYPE_LEVEL_HIGH>;
			interrupt-names = "mc";
			clocks = <&aon_gate CLK_OTG_UTMI_EB>;
			phys = <&hsphy>;

			status = "disabled";
		};
	};
};
